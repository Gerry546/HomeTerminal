FILESEXTRAPATHS:prepend:rauc := "${THISDIR}/files:"
SRC_URI:append:rauc = " file://boot.cmd.in"