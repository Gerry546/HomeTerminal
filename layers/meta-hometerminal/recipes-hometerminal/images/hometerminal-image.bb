DESCRIPTION = "Image for the hometerminal"
LICENSE = "CLOSED"

require hometerminal-common.inc
